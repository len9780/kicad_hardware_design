# Repository len9780/kicad_hardware_design

File README.md:

# kicad_hardware_design
Hardware design project collection

## KiCad design Water_Flowering_hardware/Water_Flowering_hardware.kicad_pcb

Parts:
C1: 100nF; C_0603_1608Metric
D1: D_SMA
J1: Water_Level_Sensor_Module; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
J2: Soil_Moisture_Sensor_Module; JST_EH_S4B-EH_1x04_P2.50mm_Horizontal
J3: Conn_01x02; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
J4: Power Jack; BarrelJack_GCT_DCJ200-10-A_Horizontal
J5: Conn_01x02; PinSocket_1x02_P2.54mm_Vertical
K1: Relay_SPDT; Relay_SPDT_Finder_36.11
Q1, Q2: MMBT5550L; SOT-23
R1, R2, R3, R6: 1k; R_0603_1608Metric
R4: 10K; C_0603_1608Metric
R5: 10k; R_0603_1608Metric
U1: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm
U2: WeMos_D1_mini; WEMOS_D1_mini_light

Connections:
/3.3V: C1.1, J1.2, J2.1, R5.2, R6.2, U1.24 (VCC); also elsewhere on the board
/5V: D1.1 (K), K1.A1, R1.1, R3.1, U2.9 (5V); also elsewhere on the board
/APSTA_SEL: J5.1, R5.1, U2.3 (D0)
/COM: U1.1 (COM), U2.2 (A0)
/GND: C1.2, J1.3, J2.2, J3.1, J4.2, J4.3, J5.2, Q1.2 (E), R4.2, U1.12 (GND), U2.10 (GND); also elsewhere on the board
/S0: U1.10 (S0), U2.4 (SCK/D5)
/S1: U1.11 (S1), U2.5 (MISO/D6)
/S2: U1.14 (S2), U2.14 (SCL/D1)
/S3: U1.13 (S3), U2.13 (SDA/D2)
/Soil_A0: J2.4, U1.9 (I0)
/Soil_D0: J2.3, U1.8 (I1)
/VIN: J4.1; also elsewhere on the board
/W0: J1.1, U1.7 (I2)
/Water_Out: Q2.2 (E), U2.12 (D3)
unnamed: D1.2 (A), K1.A2, Q1.3 (C)
unnamed: J3.2, K1.14
unnamed: K1.11, R3.2
unnamed: Q1.1 (B), R2.2
unnamed: Q2.1 (B), R6.1
unnamed: Q2.3 (C), R1.2, R2.1
unnamed: R4.1, U1.15 (~E)

Notes on the sheet:
外部模組連接器
建議: LT1963AxST-3.3(1.5A)

Parts:
C2: 10uF; C_0603_1608Metric
C3, C4: 1uF; C_0603_1608Metric
U3: LM1117MP-3.3; SOT-223-3_TabPin2
U4: LM1117MP-5.0; SOT-223-3_TabPin2

Connections:
/3.3V: C3.1, U3.2 (VO); also elsewhere on the board
/5V: C4.1, U4.2 (VO); also elsewhere on the board
/GND: C2.2, C3.2, C4.2, U3.1 (GND), U4.1 (GND); also elsewhere on the board
/VIN: C2.1, U3.3 (VI), U4.3 (VI); also elsewhere on the board

Notes on the sheet:
建議: LT1963AxST-3.3(1.5A)

Board: 2 copper layers, 72.2 x 36.4 mm, 24 parts (3 on the bottom side), 21 nets.

Other parts of the board:
R2#2: 1k; R_0603_1608Metric

Their connections:
/GND: R2#2.1; also elsewhere on the board

## KiCad design ble_midi_hardware/ble_midi_hardware/ble_midi_hardware.kicad_pcb

Parts:
J1: Conn_01x02_Socket; PinHeader_1x02_P2.54mm_Vertical
J2: ESP32_Left; PinHeader_1x15_P2.54mm_Vertical
J3: ESP32_Right; PinHeader_1x15_P2.54mm_Vertical
J4: Conn_To_Midi_Device; PinHeader_1x16_P2.54mm_Vertical
U1, U2: 74HC595; SOIC16

Connections:
/3.3V: U1.10 (~SRCLR), U1.16 (VCC), U2.10 (~SRCLR), U2.16 (VCC); also elsewhere on the board
/5V: J2.15; also elsewhere on the board
/GND: J1.1, J2.14, U1.8 (GND), U1.13 (~OE), U2.8 (GND), U2.13 (~OE); also elsewhere on the board
/IN1: J2.7, J4.11
/IN2: J2.6, J4.12
/IN3: J3.13, J4.15
/IN4: J3.15, J4.13
/IN5: J3.14, J4.14
/OUT1: J4.1, U1.15 (QA)
/OUT2: J4.2, U1.1 (QB)
/OUT3: J4.3, U1.2 (QC)
/OUT4: J4.4, U1.3 (QD)
/OUT5: J4.5, U1.4 (QE)
/OUT6: J4.6, U1.5 (QF)
/OUT7: J4.7, U1.6 (QG)
/OUT8: J4.8, U1.7 (QH)
/OUT9: J4.9, U2.15 (QA)
/OUT10: J4.10, U2.1 (QB)
/RCK1: J2.11, U1.12 (RCLK)
/RCK2: J2.9, U2.12 (RCLK)
/SCK1: J2.13, U1.11 (SRCLK)
/SCK2: J2.8, U2.11 (SRCLK)
/SDA1: J2.12, U1.14 (SER)
/SDA2: J2.10, U2.14 (SER)
/電源/VIN: J1.2; also elsewhere on the board

Notes on the sheet:
Scanning Output
ESP32 WROOM

Parts:
C1: 10uF; C_0603_1608Metric
C2, C3: 1uF; C_0603_1608Metric
U3: LM1117MP-3.3; SOT-223-3_TabPin2
U4: LM1117MP-5.0; SOT-223-3_TabPin2

Connections:
/3.3V: C2.1, U3.2 (VO); also elsewhere on the board
/5V: C3.1, U4.2 (VO); also elsewhere on the board
/GND: C1.2, C2.2, C3.2, U3.1 (GND), U4.1 (GND); also elsewhere on the board
/電源/VIN: C1.1, U3.3 (VI), U4.3 (VI); also elsewhere on the board

Notes on the sheet:
建議: LT1963AxST-3.3(1.5A)

Board: 2 copper layers, 68.6 x 59.3 mm, 11 parts (0 on the bottom side), 25 nets.

## Commit log

2022-04-16 electronic drum first commit
2022-04-16 arduio_piano first push
2022-04-17 add audio_PJ317.petty
2022-05-22 isp programmer schematic of arduino nano to pro mini
2024-03-20 add kicad ble midi project
2024-03-20 add kicad Water Flowering project
2024-05-19 移除孤立銅
2024-05-19 調整HC595供電5V為3.3V以及調整MCU INPUT GPIO pin腳位和部份走線
2024-05-20 調整SCK2(GPIO25)、RCK2(GPIO26)和SDA2(GPIO27)的腳位位置和pcb走線
2024-05-25 Fix: 修正JACK的VIN和GND腳位和走線和修正5V的走線
2024-05-25 Fix: 確認CD74HC4067功能後並修正相對的GPIO腳位
2024-05-25 Feat: 加入APSTA腳位到D0腳位 - 原本為pull high可進入一種模式(STA或AP)，可透過短路2PIN接地進入另一種模式
2024-05-25 Fix: 修正繼電器控制電路 - 加入準位轉換電路(3.3V-5V) - 修正繼電器控制腳位 - 結合準位轉換電路以及用5V輸出準位控制繼電器電路
2024-05-26 Docs: 在原理圖加入準位轉換和繼電器控制電路
